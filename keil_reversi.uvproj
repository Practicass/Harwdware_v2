# Keil uVision project keil_reversi.uvproj, settings and files
target Simulator (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2105 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: keil_reversi
  c flags: Optim=4 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Startup Code
    ./: Startup.s
  group System Calls
    ./: Retarget.c
  group Source Code
    ./: main.c fifo.h fifo.c gpio_hal.h eventos.h io_reserva.h linea_serie_hal.h linea_serie_hal.c linea_serie_drv.h linea_serie_drv.c planificador.c swi.h swi.s alarmas.h alarmas.c temporizador_drv.h temporizador_drv.c temporizador_hal.h temporizador_hal.c hello_world.c hello_world.h visualizar.h visualizar.c planificador.h
